# Keil uVision project MIS050_S_TEST.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MIS050_S_TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Basic\delay;.\Basic\sys;.\Hardware\Channel;.\Basic\PWM;.\Basic\usart;.\Basic\adc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/PWM/: pwm.c
    ./Basic/usart/: usart.c
    ./Basic/adc/: adc.c
  group Hardware
    ./Hardware/Channel/: Channel.c
  group User
    ./User/: main.c stm32f10x_it.c
